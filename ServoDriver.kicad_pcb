# Repository picopicodevil/ServoDriver

## KiCad design ServoDriver.kicad_pcb

Parts:
C1: 47u; CP_Radial_D5.0mm_P2.50mm
C2: 10u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C3, C5: 0.1u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C4: 0.33u; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
IC1: Si8631; SOIC127P1030X265-16N; Mouser Part Number 634-SI8631AB-B-IS
IC2: LTC485; DIP-8_W7.62mm; Manufacturer_Part_Number LTC485CN8#PBF; Mouser Part Number 584-LTC485CN8#PBF
J1: XT30-M; AMASS_XT30U-M_1x02_P5.0mm_Vertical
J2: XT30-F; AMASS_XT30U-M_1x02_P5.0mm_Vertical
J3: MCU; PinHeader_1x05_P2.54mm_Vertical
J4: Servo; JST_EH_B4B-EH-A_1x04_P2.50mm_Vertical
J5: Power_Only; JST_EH_B4B-EH-A_1x04_P2.50mm_Vertical
JP1: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
U1: L7805; TO-220-3_Vertical

Connections:
+3V3: C3.1, IC1.1 (VDD1), IC1.7 (EN1), J3.1
+5V: C5.1, IC1.10 (EN2), IC1.16 (VDD2), IC2.8 (VCC), U1.3 (OUT)
D+: IC2.6 (A), J4.2, JP1.2 (B)
D-: IC2.7 (B), J4.1
GND: C3.2, IC1.2 (GND1_1), IC1.8 (GND1_2), J3.2
GNDPWR: C1.2, C2.2, C4.2, C5.2, IC1.9 (GND2_1), IC1.15 (GND2_2), IC2.5 (GND), J1.1, J2.1, J4.4, J5.4, U1.2 (GND)
MCU_Enable: IC1.4 (A2), J3.4
MCU_RX: IC1.5 (A3), J3.5
MCU_TX: IC1.3 (A1), J3.3
TRX_Enable: IC1.13 (B2), IC2.2 (~RE), IC2.3 (DE)
TRX_RX: IC1.12 (B3), IC2.1 (RO)
TRX_TX: IC1.14 (B1), IC2.4 (DI), JP1.1 (A)
VCC: C1.1, C2.1, C4.1, J1.2, J2.2, J4.3, J5.3, U1.1 (IN)

Board: 2 copper layers, 57.0 x 33.0 mm, 18 parts (0 on the bottom side), 13 nets.

## Commit log

2020-02-17 add
    試作
2020-02-17 clean
2020-02-18 change
    ジャンパを使ってPWMとコマンド方式を切り替えられるように変更
2020-02-18 add
    Si8632を使っても動作させられるように変更
2020-02-19 fix
    PWM用のジャンパの結線ミスを修正
2020-02-19 clean
    回路図の情報を修正
2020-02-19 order from fusion pcb
2020-02-19 Rename PCB
2020-06-30 change
2021-09-24 Remove: ガーバーファイルを削除
2021-09-24 Add: .gitignore
2021-09-24 Remove: バックアップファイル
2021-09-24 Update:
2021-09-24 Create LICENSE
2021-09-24 Remove: 発注用ファイル
